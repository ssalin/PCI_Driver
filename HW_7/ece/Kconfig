## HW_7/ece/Kconfig
```kconfig
config ECE
	tristate "ECE light driver"
	depends on PCI
	default y
	help
	  Blinks Lights on back of atom box
```
